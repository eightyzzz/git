# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,RTE_DEVICE_FRAMEWORK_CLASSIC,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ..\app;..\app\font;..\app\image;..\app\page;..\app\storage;..\driver;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\third_lib\flashdb\inc;..\third_lib\flashdb\port\fal\inc;..\third_lib\freertos;..\third_lib\freertos\include;..\third_lib\freertos\portable;..\third_lib\littlefs;..\third_lib\lvgl;..\third_lib\usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c board.c app.c wifi.c weather.c workqueue.c
  group app/font
    ../app/font/: lv_font_cn.c
  group app/image
    ../app/font/: lv_font_time_68.c
  group driver
    ../driver/: espat.c st7789.c console.c rtc.c aht20.c tim_delay.c ft6336.c spi_flash.c usb_mtp.c
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/freetros
    ../third_lib/freertos/: list.c queue.c tasks.c timers.c
    ../third_lib/freertos/portable/: heap_4.c port.c
  group lvgl
    ../third_lib/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../third_lib/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../third_lib/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../third_lib/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../third_lib/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../third_lib/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../third_lib/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../third_lib/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../third_lib/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../third_lib/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../third_lib/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../third_lib/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../third_lib/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../third_lib/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../third_lib/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../third_lib/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../third_lib/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../third_lib/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../third_lib/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../third_lib/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../third_lib/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../third_lib/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../third_lib/lvgl/src/extra/: lv_extra.c
    ../third_lib/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../third_lib/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../third_lib/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../third_lib/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../third_lib/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../third_lib/lvgl/src/extra/others/msg/: lv_msg.c
    ../third_lib/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../third_lib/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../third_lib/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../third_lib/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../third_lib/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../third_lib/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../third_lib/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../third_lib/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../third_lib/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../third_lib/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../third_lib/lvgl/src/extra/widgets/led/: lv_led.c
    ../third_lib/lvgl/src/extra/widgets/list/: lv_list.c
    ../third_lib/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../third_lib/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../third_lib/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../third_lib/lvgl/src/extra/widgets/span/: lv_span.c
    ../third_lib/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../third_lib/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../third_lib/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../third_lib/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../third_lib/lvgl/src/extra/widgets/win/: lv_win.c
    ../third_lib/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c lv_font_montserrat_20.c lv_font_montserrat_28.c lv_font_montserrat_32.c lv_font_montserrat_48.c
    ../third_lib/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../third_lib/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../third_lib/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group app/lvgl
    ../app/: lvgl_ui.c lv_port_disp.c lv_port_indev.c
  group app/storage
    ../app/storage/: storage.c lfs_port.c lv_fs_lfs.c fal_flash_w25q128.c
  group third_lib/littlefs
    ../third_lib/littlefs/: lfs.c lfs_util.c
  group third_lib/flashdb
    ../third_lib/flashdb/src/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    ../third_lib/flashdb/port/fal/src/: fal.c fal_flash.c fal_partition.c
  group third_lib/usb
    ../third_lib/usb/: USBD_FS_STM32F4xx.c
